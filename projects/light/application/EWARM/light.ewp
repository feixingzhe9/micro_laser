# IAR project light.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; STM32F103xB; STM32F103x8; USE_STDPERIPH_DRIVER; xSIZE_OPTIMIZE; NO_MICO_RTOS; MICO_DISABLE_WATCHDOG; DEBUG=1; NO_BLOCK_MENU
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Inc; ..\..\..\..\platforms\MCUs\STM32F1xx; ..\..\..\..\board; ..\..\..\..\kernel\RTOS\NoRTOS; ..\..\..\..\bootloader; ..\..\..\..\platforms\MCUs\STM32F1xx\EWARM; ..\..\..\..\platforms\Cortex-M3\CMSIS\Include; ..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries; ..\..\..\..\platforms\Cortex-M3\CMSIS\Device\ST\STM32F1xx\Include; ..\..\..\..\platforms\include; ..\..\..\..\include; ..\..\..\..\include\MiCODrivers; ..\..\..\..\board\Ultrasonic; ..\..\..\..\platforms\Cortex-M3; ..\..\..\..\platforms\MCUs\STM32F1xx\peripherals; ..\..\..\..\library\utilities; ..\..\..\..\kernel\security\Curve25519; ..\..\..\..\kernel\security; ..\..\..\..\kernel\RTOS\FreeRTOS\Source\include; ..\..\..\..\kernel\RTOS\FreeRTOS\Source\portable\IAR\ARM_CM3; ..\..\..\..\kernel\RTOS\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\kernel\RTOS\FreeRTOS; ..\..\..\..\application\platform; ..\..\..\..\vl53l0x
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\kernel\RTOS\FreeRTOS
  OBJCOPY.OOCOutputFile: Ultrasonic-Single.bin
  ILINK.IlinkOutputFile: PowerBoard_Application.out
  ILINK.IlinkIcfFile: ..\..\..\..\board\Ultrasonic\applicationLinkerForIAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
configuration RTOS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F103xE; xSIZE_OPTIMIZE; xNO_MICO_RTOS; MICO_DISABLE_WATCHDOG
  ICCARM.CCIncludePath2: ..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Inc; ..\..\..\..\platforms\MCUs\STM32F1xx; ..\..\..\..\board; ..\..\..\..\kernel\RTOS\NoRTOS; ..\..\..\..\bootloader; ..\..\..\..\platforms\MCUs\STM32F1xx\EWARM; ..\..\..\..\platforms\Cortex-M3\CMSIS\Include; ..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries; ..\..\..\..\platforms\Cortex-M3\CMSIS\Device\ST\STM32F1xx\Include; ..\..\..\..\platforms\include; ..\..\..\..\include; ..\..\..\..\include\MiCODrivers; ..\..\..\..\board\PowerBoard_V2; ..\..\..\..\platforms\Cortex-M3; ..\..\..\..\platforms\MCUs\STM32F1xx\peripherals; ..\..\..\..\library\utilities; ..\..\..\..\kernel\security\Curve25519; ..\..\..\..\kernel\security; ..\..\..\..\kernel\RTOS\FreeRTOS\Source\include; ..\..\..\..\kernel\RTOS\FreeRTOS\Source\portable\IAR\ARM_CM3; ..\..\..\..\kernel\RTOS\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\kernel\RTOS\FreeRTOS
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: PowerBoard_Application.bin
  ILINK.IlinkIcfFile: E:\SuperMcuOS\board\PowerBoard_V2\applicationLinkerForIAR.icf
configuration test (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: PowerBoard_Application.bin
  ILINK.IlinkIcfFile: as above
  group Application
    ../../../../application/: application.c Getline.c menu.c Update_for_OTA.c ymodem.c
  group Application/platform
    ../../../../application/platform/: app_platform.c app_platform.h can_protocol.c can_protocol.h fifo.c protocol.h serial_leds.h serial_uart.c serial_uart.h uart_protocol.c upgrade_flash.c upgrade_flash.h
  group Board/Light
    ../../../../board/Ultrasonic/: board_init.c platform.c
  group include
    ../../../../include/: common.h debug.h mico.h mico_platform.h mico_rtos.h mico_security.h mico_socket.h mico_system.h MiCOSRPServer.h
  group include/MicoDriver
    ../../../../include/MiCODrivers/: MiCODriverAdc.h MiCODriverCan.h MiCODriverFlash.h MiCODriverGpio.h MiCODriverI2c.h MiCODriverMFiAuth.h MiCODriverNanoSecond.h MiCODriverPwm.h MiCODriverRng.h MiCODriverRtc.h MiCODriverSpi.h MiCODriverUart.h MiCODriverWdg.h
  group kernel
    ../../../../kernel/RTOS/NoRTOS/: rtos.c
  group kernel/FreeRTOS
    ../../../../kernel/RTOS/FreeRTOS/: FreeRTOSConfig.h mico_rtos.c
    ../../../../kernel/RTOS/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group kernel/FreeRTOS/CMSIS_RTOS
    ../../../../kernel/RTOS/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group kernel/FreeRTOS/portable
    ../../../../kernel/RTOS/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../kernel/RTOS/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group libraries/utilities
    ../../../../library/utilities/: AESUtils.c CheckSumUtils.c LibMd5.c RingBufferUtils.c SecurityUtils.c StringUtils.c TLVUtils.c URLUtils.c
  group Platform/Cortex-M3
    ../../../../platforms/Cortex-M3/: crt0_EWARM.c hardfault.c
  group Platform/EWARM
    ../../../../platforms/EWARM/: Retarget.c
  group Platform/STM32F1xx
    ../../../../platforms/MCUs/: mico_platform_common.c
    ../../../../platforms/MCUs/STM32F1xx/: platform_init.c
  group Platform/STM32F1xx/EWARM
    ../../../../platforms/MCUs/STM32F1xx/EWARM/: startup_stm32f103xe_application_EWARM.s
  group Platform/STM32F1xx/Peripherals
    ../../../../platforms/MCUs/STM32F1xx/peripherals/: nbosDriverFlash.c platform_can.c platform_flash.c platform_gpio.c platform_mcu_powersave.c platform_pwm.c platform_tim.c platform_uart.c platform_watchdog.c
  group Platform/STM32F1xx/Peripherals/Libraries
    ../../../../platforms/MCUs/STM32F1xx/peripherals/libraries/: stm32f1xx_hal_conf.h system_stm32f1xx.c
  group Platform/STM32F1xx/Peripherals/Libraries/STM32F1xx_HAL_Driver
    ../../../../platforms/MCUs/STM32F1xx/peripherals/libraries/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_msp_template.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_usb.c
  group Vl53l0x
    ../../../../vl53l0x/: global.c i2c.c VL53L0.c vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_strings.c vl53l0x_platform.c
